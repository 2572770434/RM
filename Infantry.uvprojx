# Keil uVision project Infantry.uvprojx, settings and files
target Infantry (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\BSP;.\COMMON;.\CORE;.\STLibraries\inc;.\USER;.\TASK;.\RmLib;.\BSP;.\DSPLIB;.\DSPLIB\Include;.\KALMAN;.\Fuzzy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ./BSP/: bsp.c can1.c can2.c usart3.c timer.c gun.c usart1.c usart2.c usart6.c
    ./USER/: main.c
  group ControlTask
    ./TASK/: ControlTask.c SpeedTask.c WorkState.c
    ./BSP/: usart7.c
  group CanBusTask
    ./TASK/: CanBusTask.c encoder.c
  group RemoteTask
    ./TASK/: MouseKeyControl.c RemoteTask.c InputState.c
  group SuperviseTask
    ./TASK/: RemoteControl.c SuperviseTask.c
  group COMMON
    ./COMMON/: dataprocess.c delay.c crc.c
  group STLIB
    ./STLibraries/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group RMLib
    ./RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h RMLib.lib
  group CORE
    ./CORE/: startup_stm32f427xx.s
  group MSPLIB
    ./DSPLIB/: arm_cortexM4lf_math.lib
  group KALMAN
    ./KALMAN/: Kalman.c VectorOpt.c MatrixOpt.c KALMANTEST.c
  group Fuzzy
    ./Fuzzy/: pid_fuzzy.c
